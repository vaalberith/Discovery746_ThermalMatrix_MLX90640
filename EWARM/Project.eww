<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Discovery_GFX.ewp</path>
  </project>
  <batchBuild />
</workspace>
